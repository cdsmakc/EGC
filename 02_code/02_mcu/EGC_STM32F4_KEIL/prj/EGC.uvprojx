# Keil uVision project EGC.uvprojx, settings and files
target EGC (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F429BITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: EGC
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F429_439xx USE_STDPERIPH_DRIVER
  c include: ..\src\ST\CMSIS;..\src\ST\lib\inc;..\src\ST\misc;..\src\uC-OS\config;..\src\uC-OS\uC-CPU;..\src\uC-OS\uC-CPU\ARM-Cortex-M4\RealView;..\src\uC-OS\uC-LIB;..\src\uC-OS\uC-LIB\Ports;..\src\uC-OS\uC-LIB\Ports\ARM-Cortex-M4\RealView;..\src\uC-OS\uCOS-III\Ports\ARM-Cortex-M4\Generic\RealView;..\src\uC-OS\uCOS-III\Source;..\src\user\drv\MCU_Periph;..\src\user\drv;..\src\user\pub;..\src\user
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group user
    ../src/user/: EGC.c EGC_LG1.c EGC_LG2.c sys_cfg.c sys_interrupt.c EGC_MSR.c EGC_ESP.c EGC_CTL.c EGC_HST.c
    ../src/user/pub/: pub_lib.c
  group ST
    ../src/ST/CMSIS/: arm_cortexM4lf_math.lib
    ../src/ST/lib/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    ../src/ST/startup/: cstartup.s
  group uC/OS-III
    ../src/uC-OS/config/: os_app_hooks.c
    ../src/uC-OS/uC-CPU/: cpu_core.c
    ../src/uC-OS/uC-CPU/ARM-Cortex-M4/RealView/: cpu_a.asm cpu_c.c
    ../src/uC-OS/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../src/uC-OS/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
    ../src/uC-OS/uCOS-III/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu_a.asm os_cpu_c.c
    ../src/uC-OS/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_pend_multi.c os_mutex.c os_prio.c os_sem.c os_q.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group drv
    ../src/user/drv/MCU_Periph/: drv_sdram_stm32f4xx.c drv_spi_stm32f4xx.c drv_uart_stm32f4xx.c drv_i2c_stm32f4xx.c
    ../src/user/drv/: drv_hdc1080.c drv_msa300.c drv_w25q.c
